File: R-PCBA-VPEG-PWR.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: First draft of the schematic
Other:
- removed sheet Power - Sequencing
